Commit message: update ps5

File: my_ps4/ps4_model/ps4_model.urdf (robot description, URDF)
Before this commit: robot one_DOF_robot, 4 links, 3 joints
Links:
- link link3: geometry collision cylinder length=2 radius=0.05; visual cylinder length=2 radius=0.05
